v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {res.sym} 20 10 0 0 {name=R1
value=1k
footprint=1206
device=resistor
m=1}
